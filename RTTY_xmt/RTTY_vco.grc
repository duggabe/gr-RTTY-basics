options:
  parameters:
    author: Barry Duggan
    description: RTTY transmitter
    generate_options: qt_gui
    id: RTTY_vco
    output_language: python
    title: RTTY_vco
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 1/0.022
  states: {}
- name: center
  id: variable
  parameters:
    value: '2210'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: ((center+(fsk_deviation/2))/vco_max)-vco_offset
  states: {}
- name: repeat
  id: variable
  parameters:
    value: (int)(samp_rate*0.022)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: (center-(fsk_deviation/2))/vco_max
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: vco_offset
    const: vco_offset
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: inp_amp
    const: inp_amp
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: '15708'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Baudot code vector source
      """

      import numpy as np
      from gnuradio import gr

      import pmt

      ITA2 = [ 0x00, 'E', '\n', 'A', ' ', 'S', 'I', 'U', '\r', 'D', 'R', 'J', 'N', 'F', 'C', 'K',
                  'T', 'Z', 'L', 'W', 'H', 'Y', 'P', 'Q', 'O', 'B', 'G', 0x0e, 'M', 'X', 'V', 0x0f,
                  0x00, '3', '\n', '-', ' ', 0x07, '8', '7', '\r', '$', '4', '\'', ',', '!', ':', '(',
                  '5', '\"', ')', '2', '#', '6', '0', '1', '9', '?', '&', 0x0e, '.', '/', ';', 0x0f ]

      textboxValue = ""
      _figs = 0x1b
      _ltrs = 0x1f
      _shift = 0
      bit_stream = []
      CQita2 =  []

      class mc_sync_block(gr.sync_block):
          """
          reads input from a message port
          generates a vector of Baudot code bits
          """
          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Baudot code vector source",
                  in_sig = None,
                  out_sig = [np.byte])
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('clear_input'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              global textboxValue
              textboxValue = pmt.symbol_to_string (msg)
              # print (textboxValue)
          
          def work(self, input_items, output_items):
              global ITA2
              global textboxValue
              global _figs
              global _ltrs
              global _shift
              global bit_stream
              global CQita2

      #       convert UTF-8 to ITA2 (Baudot)
              if (len (textboxValue) > 0):
                  bit_stream = [ 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1, 1 ]
                  CQita2 = [31, 31]    # LTRS
                  _shift = 0
                  for in0 in textboxValue:
                      # get next char
                      inChar = str (in0)
                      # convert to upper case
                      ch = inChar.upper()
                      # test for character in ITA2
                      if (ch in ITA2):
                          _idx = ITA2.index (ch)
      #                   if (not space)
                          if (ch != ' '):
      #                       if index > 31       // figures
                              if (_idx > 31):
                                  if (_shift == 0):
                                      CQita2.append (0x1b)    # send 'figures' code
                                      _shift = 0x20
                              else:                    # letters
                                  if (_shift > 0):
                                      CQita2.append (0x1f)     # send 'letters' code
                                      _shift = 0
      #                   store ITA2 char
                          _idx &= 0x1F
                          CQita2.append (int(_idx))
                      else:
                          CQita2.append (4)    # space
                  CQita2.append (8)    # CR
                  CQita2.append (8)    # CR
                  CQita2.append (2)    # LF
      #            print ("CQita2:")
      #            print (CQita2)

      #           serialize data LSB first
                  for _out in CQita2:
                      outDat = _out
                      _bit_count = 0
                      while _bit_count < 8:
                          if (_bit_count == 0):
                              bit_stream.append (int(0))    # start bit
                          elif (_bit_count > 5):
                              bit_stream.append (int(1))    # stop bits
                          else:
                              bit_stream.append (int(outDat & 1))
                              outDat >>= 1
                          _bit_count += 1
      #            print ("bit_stream:")
      #            print (bit_stream)

                  # get length of string
                  _num_elem = len(bit_stream)
      #            print ("num elements = ", _num_elem)

                  # copy bit_stream to output array
                  for x in range (_num_elem):
                      output_items[0][x] = bit_stream[x]

                  # clear input line
                  textboxValue = ""
                  self.message_port_pub(pmt.intern('clear_input'), pmt.intern(''))
              else:
                  _num_elem = 0

              return (_num_elem)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '1.5'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50251
    timeout: '100'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_f_0, '0', low_pass_filter_0, '0']
- [epy_block_0_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '1']
- [zeromq_pull_msg_source_0, out, epy_block_0_0, msg_in]

metadata:
  file_format: 1
